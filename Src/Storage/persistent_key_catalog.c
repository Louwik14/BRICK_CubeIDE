#include "Storage/persistent_key_catalog.h"
#include "Track/entity_topology.h"
#include "Track/track_runtime.h"
#include "Seq/seq_param_iface.h"
#include <stddef.h>

static const persist_control_parameter_key_t g_param_keys[PARAM_COUNT]={
    [PARAM_MIX_MUTE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x162521UL),
    [PARAM_CFG_POLY_SPREAD] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_CONFIG, 0x693CF0UL),
    [PARAM_DRUM_MD_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x922B23UL),
    [PARAM_DRUM_MD_P1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77D559UL),
    [PARAM_DRUM_MD_P2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77D0A0UL),
    [PARAM_DRUM_MD_P3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77D233UL),
    [PARAM_DRUM_MD_P4] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77DA12UL),
    [PARAM_DRUM_MD_P5] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77DBA5UL),
    [PARAM_DRUM_MD_P6] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77D6ECUL),
    [PARAM_DRUM_MD_P7] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77D87FUL),
    [PARAM_DRUM_MD_P8] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x77E05EUL),
    [PARAM_MIX_SEND0_FX] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x952A11UL),
    [PARAM_MIX_SEND1_FX] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x821BB0UL),
    [PARAM_MIX_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x8AE43EUL),
    [PARAM_MIX_PAN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xB7285FUL),
    [PARAM_MIX_SEND1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x5FDEB5UL),
    [PARAM_MIX_SEND2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x5FD9FCUL),
    [PARAM_MIX_SEND3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x5FD543UL),
    [PARAM_MODFX_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31001UL),
    [PARAM_MODFX_RATE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31002UL),
    [PARAM_MODFX_DEPTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31003UL),
    [PARAM_MODFX_FEEDBACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31004UL),
    [PARAM_MODFX_OFFSET] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31005UL),
    [PARAM_MODFX_RATE_B] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31006UL),
    [PARAM_MODFX_DELAY_B] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31007UL),
    [PARAM_MODFX_DEPTH_B] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31008UL),
    [PARAM_MODFX_WIDTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA31009UL),
    [PARAM_BUS_COMP_THRESHOLD_DB] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xDB0E26UL),
    [PARAM_BUS_COMP_RATIO] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xAC8DF3UL),
    [PARAM_BUS_COMP_ATTACK_INDEX] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x21D56FUL),
    [PARAM_BUS_COMP_RELEASE_INDEX] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xE4748AUL),
    [PARAM_BUS_COMP_MAKEUP_DB] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xF51272UL),
    [PARAM_BUS_COMP_AUTO_MAKEUP] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x7FA34FUL),
    [PARAM_BUS_COMP_DRYWET] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x7A688BUL),
    [PARAM_BUS_COMP_HPF_HZ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x1F6E3DUL),
    [PARAM_EQ_LOW_DB] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x7865F7UL),
    [PARAM_EQ_MID_DB] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xF2F2BFUL),
    [PARAM_EQ_HIGH_DB] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xEB37A5UL),
    [PARAM_SAT_TONE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x05F52AUL),
    [PARAM_SAT_BIAS] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xCF37E7UL),
    [PARAM_SAT_DRIVE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xB96A76UL),
    [PARAM_SAT_MIX] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xA95D3CUL),
    [PARAM_FILTER_MORPH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xA0A22AUL),
    [PARAM_FILTER_CUTOFF] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xEE7B67UL),
    [PARAM_FILTER_RESONANCE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xFE50BEUL),
    [PARAM_FILTER_EG_AMT] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xA5AF1FUL),
    [PARAM_FILTER_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xAA47E6UL),
    [PARAM_FILTER_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x8F2DE8UL),
    [PARAM_FILTER_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x52A30BUL),
    [PARAM_FILTER_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x8F526BUL),
    [PARAM_FILTER_KEYTRK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x519A24UL),
    [PARAM_FILTER_ENVRST] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x97A90AUL),
    [PARAM_FILTER_ENVDLY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x906D14UL),
    [PARAM_FILTER_DRIVE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xDE1A6EUL),
    [PARAM_FILTER_DECIMATOR_BITS] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x822741UL),
    [PARAM_FILTER_DECIMATOR_RATE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x49FE5FUL),
    [PARAM_FILTER_DECIMATOR_RATE2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x7B8597UL),
    [PARAM_VCA_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x804460UL),
    [PARAM_VCA_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xC90A72UL),
    [PARAM_VCA_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x89398DUL),
    [PARAM_VCA_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x7598C9UL),
    [PARAM_MASTER_GAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x47C069UL),
    [PARAM_POST_GAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xB5D035UL),
    [PARAM_OUTPUT_COMP] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x12D31CUL),
    [PARAM_DRUM_TRX_BD_PITCH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA8DFC0UL),
    [PARAM_DRUM_TRX_BD_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE63200UL),
    [PARAM_DRUM_TRX_BD_PITCH_SWEEP] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAC497BUL),
    [PARAM_DRUM_TRX_BD_SWEEP_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x446D53UL),
    [PARAM_DRUM_TRX_BD_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x766C0EUL),
    [PARAM_DRUM_TRX_BD_NOISE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC0236CUL),
    [PARAM_DRUM_TRX_BD_HARMONICS] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x64CF1EUL),
    [PARAM_DRUM_TRX_BD_DRIVE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x699CC6UL),
    [PARAM_LFO1_RATE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0xE62A04UL),
    [PARAM_LFO1_SHAPE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x5F5F83UL),
    [PARAM_LFO1_TRIG] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x0139C8UL),
    [PARAM_LFO1_PHASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x9A85EDUL),
    [PARAM_LFO2_RATE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0xFA5A93UL),
    [PARAM_LFO2_SHAPE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x802FD2UL),
    [PARAM_LFO2_TRIG] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x601ED7UL),
    [PARAM_LFO2_PHASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x69FE14UL),
    [PARAM_LFO3_RATE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x57225AUL),
    [PARAM_LFO3_SHAPE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x14E10DUL),
    [PARAM_LFO3_TRIG] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0xDDAB62UL),
    [PARAM_LFO3_PHASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MOD, 0x7D038FUL),
    [PARAM_ENV3_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xE64AB8UL),
    [PARAM_ENV3_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x76303AUL),
    [PARAM_ENV3_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xB2EC25UL),
    [PARAM_ENV3_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xBA3C91UL),
    [PARAM_ENV_RETRIG_FILTER] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xFDFD97UL),
    [PARAM_ENV_RETRIG_VCA] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x80C6EDUL),
    [PARAM_ENV_RETRIG_MOD] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0x921603UL),
    [PARAM_MIX_REVERB_WET] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x90DBEBUL),
    [PARAM_MIX_REVERB_ROOM_SIZE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x1275BAUL),
    [PARAM_MIX_REVERB_DAMPING] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x49AD31UL),
    [PARAM_MIX_REVERB_WIDTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x1ABCF3UL),
    [PARAM_MIX_REVERB_HPF] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x9D95BDUL),
    [PARAM_MIX_REVERB_LPF] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xFA5851UL),
    [PARAM_MIX_DELAY_TYPE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xB2DE20UL),
    [PARAM_MIX_DELAY_TIME] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x0FF741UL),
    [PARAM_MIX_DELAY_PINGPONG] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x0A5A9AUL),
    [PARAM_MIX_DELAY_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x5B871BUL),
    [PARAM_MIX_DELAY_TIME_R] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x8CEFB8UL),
    [PARAM_MIX_DELAY_WIDTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x775784UL),
    [PARAM_MIX_DELAY_FEEDBACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x91E8CFUL),
    [PARAM_MIX_DELAY_SPECTRAL_POSITION] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xE2A722UL),
    [PARAM_MIX_DELAY_SPECTRAL_WIDTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x80A197UL),
    [PARAM_MIX_DELAY_FBW] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x3AD49DUL),
    [PARAM_MIX_REVERB_DELAYS] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xE8865DUL),
    [PARAM_MIX_DELAY_MOD] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xC1F91CUL),
    [PARAM_MIX_DELAY_MOD_RATE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x259AABUL),
    [PARAM_MIX_DELAY_REV] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0xCC5525UL),
    [PARAM_MIX_DELAY_VOL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x9F5ED9UL),
    [PARAM_SAMPLER_GAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xB28A51UL),
    [PARAM_SAMPLER_START] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x55C86EUL),
    [PARAM_SAMPLER_LENGTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE7DCBBUL),
    [PARAM_SAMPLER_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x60D9C5UL),
    [PARAM_SAMPLER_TUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x16FFD8UL),
    [PARAM_SAMPLER_SLICE_COUNT] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x7DFB70UL),
    [PARAM_PRISM_OSC1_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAD8011UL),
    [PARAM_PRISM_VOLUME] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x721FEDUL),
    [PARAM_PRISM_TUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xEB8024UL),
    [PARAM_PRISM_PITCH_MOD1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xB3299CUL),
    [PARAM_PRISM_OSC1_PARAM1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF902F4UL),
    [PARAM_PRISM_OSC1_AMOD] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4B535BUL),
    [PARAM_PRISM_OSC1_PARAM2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x5D74F8UL),
    [PARAM_PRISM_PHASE1_RESET] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x950720UL),
    [PARAM_PRISM_BALANCE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x8732FDUL),
    [PARAM_PRISM_OSC2_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x6F41C3UL),
    [PARAM_PRISM_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x9B59E7UL),
    [PARAM_PRISM_PITCH_MOD2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE71092UL),
    [PARAM_PRISM_OSC2_PARAM1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x23514EUL),
    [PARAM_PRISM_OSC2_AMOD] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xCC4789UL),
    [PARAM_PRISM_OSC2_PARAM2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x3E9D7EUL),
    [PARAM_PRISM_DRIFT] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC05C1EUL),
    [PARAM_STACK_OSC1_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x8C2229UL),
    [PARAM_STACK_OSC2_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x88F494UL),
    [PARAM_STACK_OSC3_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA1772FUL),
    [PARAM_STACK_NOISE_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC68081UL),
    [PARAM_STACK_OSC1_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4C7336UL),
    [PARAM_STACK_OSC1_TUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC8931FUL),
    [PARAM_STACK_OSC1_TIMBRE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA5E5C8UL),
    [PARAM_STACK_OSC1_COLOR] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD8EB24UL),
    [PARAM_STACK_OSC2_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD43473UL),
    [PARAM_STACK_OSC2_TUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xCEAFD0UL),
    [PARAM_STACK_OSC2_TIMBRE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4B4D7BUL),
    [PARAM_STACK_OSC2_COLOR] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4C5E69UL),
    [PARAM_STACK_OSC3_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAC320CUL),
    [PARAM_STACK_OSC3_TUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xB496C9UL),
    [PARAM_STACK_OSC3_TIMBRE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x70614EUL),
    [PARAM_STACK_OSC3_COLOR] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x274D7EUL),
    [PARAM_STACK_OSC_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA7C027UL),
    [PARAM_STACK_PHASE_RESET] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xB234B5UL),
    [PARAM_MIDI_PROGRAM] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x998035UL),
    [PARAM_MIDI_CC1_1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE87EBCUL),
    [PARAM_MIDI_CC1_2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE88375UL),
    [PARAM_MIDI_CC1_3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE881E2UL),
    [PARAM_MIDI_CC1_4] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE87A03UL),
    [PARAM_MIDI_CC2_1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xFC8201UL),
    [PARAM_MIDI_CC2_2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xFC7D48UL),
    [PARAM_MIDI_CC2_3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xFC7EDBUL),
    [PARAM_MIDI_CC2_4] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xFC86BAUL),
    [PARAM_MIDI_CC3_1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD58F46UL),
    [PARAM_MIDI_CC3_2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD58DB3UL),
    [PARAM_MIDI_CC3_3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD58C20UL),
    [PARAM_MIDI_CC3_4] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD59725UL),
    [PARAM_SAMPLER_CLIP_SOURCE_BPM] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD2A576UL),
    [PARAM_SAMPLER_CLIP_SYNC_LENGTH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xEDD4FFUL),
    [PARAM_SAMPLER_CLIP_PITCH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x9C27A1UL),
    [PARAM_SAMPLER_CLIP_PLAY_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x71AE67UL),
    [PARAM_SAMPLER_CLIP_LOOP] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x66877BUL),
    [PARAM_SAMPLER_CLIP_STRETCH_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x1A1318UL),
    [PARAM_SAMPLER_CLIP_GRAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x43CF1CUL),
    [PARAM_FILTER_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_ENV, 0xAD784CUL),
    [PARAM_FM_RATIO] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x1D3F0AUL),
    [PARAM_FM_ALGORITHM] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x8BF42CUL),
    [PARAM_FM_FEEDBACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x80D3D4UL),
    [PARAM_FM_SYNC] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x825BC8UL),
    [PARAM_FM_BRIGHT] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xB45353UL),
    [PARAM_FM_BODY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x256507UL),
    [PARAM_FM_DETAIL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x73D06EUL),
    [PARAM_FM_METAL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x71552AUL),
    [PARAM_FM_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC98D5FUL),
    [PARAM_FM_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE109AFUL),
    [PARAM_FM_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x150484UL),
    [PARAM_FM_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x3203CCUL),
    [PARAM_LOOPER_XFADE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x50A8A7UL),
    [PARAM_LOOPER_STRETCH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x8DC300UL),
    [PARAM_LOOPER_PITCH] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x9D041FUL),
    [PARAM_LOOPER_GRAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xCD7782UL),
    [PARAM_SAMPLER_MULTI_LOOP] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4A22F6UL),
    [PARAM_SAMPLER_LOOP_START] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x8D74F3UL),
    [PARAM_WAVE_OSC1_POS] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62002UL),
    [PARAM_WAVE_OSC1_START] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62003UL),
    [PARAM_WAVE_OSC1_LEN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62004UL),
    [PARAM_WAVE_OSC2_POS] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62006UL),
    [PARAM_WAVE_OSC2_START] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62007UL),
    [PARAM_WAVE_OSC2_LEN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62008UL),
    [PARAM_WAVE_VOLUME] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA62009UL),
    [PARAM_WAVE_BALANCE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA6200AUL),
    [PARAM_WAVE_TUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA6200BUL),
    [PARAM_WAVE_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA6200CUL),
    [PARAM_COMP_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x3FB3A6UL),
    [PARAM_COMP_DETECT] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x555D56UL),
    [PARAM_COMP_KNEE_DB] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x828D25UL),
    [PARAM_COMP_DELUGE_SAT] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_MIX, 0x64EBAAUL),
    [PARAM_MIDI_FX_S1_PARAM1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF0287FUL),
    [PARAM_MIDI_FX_S1_PARAM2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF02A12UL),
    [PARAM_MIDI_FX_S1_PARAM3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF02BA5UL),
    [PARAM_MIDI_FX_S1_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x800B04UL),
    [PARAM_MIDI_FX_S2_PARAM1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x6BA6F0UL),
    [PARAM_MIDI_FX_S2_PARAM2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x6BABA9UL),
    [PARAM_MIDI_FX_S2_PARAM3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x6BAA16UL),
    [PARAM_MIDI_FX_S2_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x2AB61DUL),
    [PARAM_MIDI_FX_S3_PARAM1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x276A45UL),
    [PARAM_MIDI_FX_S3_PARAM2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x27658CUL),
    [PARAM_MIDI_FX_S3_PARAM3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x27671FUL),
    [PARAM_MIDI_FX_S3_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x96E50EUL),
    [PARAM_AUDIO_FX_P1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0101UL),
    [PARAM_AUDIO_FX_P2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0102UL),
    [PARAM_AUDIO_FX_P3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0103UL),
    [PARAM_AUDIO_FX_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0104UL),
    [PARAM_AUDIO_FX_B_P1] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0201UL),
    [PARAM_AUDIO_FX_B_P2] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0202UL),
    [PARAM_AUDIO_FX_B_P3] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0203UL),
    [PARAM_AUDIO_FX_B_MODEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0204UL),
    [PARAM_GROUP_FX_A_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0401UL),
    [PARAM_GROUP_FX_B_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAF0402UL),
    [PARAM_FM_PLAY_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x85CA99UL),
    [PARAM_FM_PLAY_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF624FDUL),
    [PARAM_FM_PLAY_PITCH_ENV] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x8299C0UL),
    [PARAM_FM_PLAY_PITCH_TIME] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE3B4C8UL),
    [PARAM_FM_OP1_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xB7817AUL),
    [PARAM_FM_OP1_FREQ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x077D7EUL),
    [PARAM_FM_OP1_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x7F1499UL),
    [PARAM_FM_OP1_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x302380UL),
    [PARAM_FM_OP1_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x43BFD2UL),
    [PARAM_FM_OP1_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xDE086DUL),
    [PARAM_FM_OP1_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xFCFFA9UL),
    [PARAM_FM_OP1_ON] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE4614DUL),
    [PARAM_FM_OP1_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x102C07UL),
    [PARAM_FM_OP1_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA9873FUL),
    [PARAM_FM_OP1_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x2E8B03UL),
    [PARAM_FM_OP2_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAB70DBUL),
    [PARAM_FM_OP2_FREQ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x3359DDUL),
    [PARAM_FM_OP2_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE6A816UL),
    [PARAM_FM_OP2_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xA26D6BUL),
    [PARAM_FM_OP2_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x575C13UL),
    [PARAM_FM_OP2_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD278C0UL),
    [PARAM_FM_OP2_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xCA0E00UL),
    [PARAM_FM_OP2_ON] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF3A1F6UL),
    [PARAM_FM_OP2_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4B53C4UL),
    [PARAM_FM_OP2_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4514CEUL),
    [PARAM_FM_OP2_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD4C702UL),
    [PARAM_FM_OP3_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAFD6C0UL),
    [PARAM_FM_OP3_FREQ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xEB7924UL),
    [PARAM_FM_OP3_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4A7693UL),
    [PARAM_FM_OP3_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC9379AUL),
    [PARAM_FM_OP3_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x343BE4UL),
    [PARAM_FM_OP3_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x54C6BFUL),
    [PARAM_FM_OP3_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x3208C7UL),
    [PARAM_FM_OP3_ON] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x0D28ABUL),
    [PARAM_FM_OP3_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x52D699UL),
    [PARAM_FM_OP3_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x237D45UL),
    [PARAM_FM_OP3_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x1EF2F9UL),
    [PARAM_FM_OP4_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x36E101UL),
    [PARAM_FM_OP4_FREQ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xBAB39BUL),
    [PARAM_FM_OP4_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x82FAA0UL),
    [PARAM_FM_OP4_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD91CFDUL),
    [PARAM_FM_OP4_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xC11FBDUL),
    [PARAM_FM_OP4_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF6426AUL),
    [PARAM_FM_OP4_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAA5C9EUL),
    [PARAM_FM_OP4_ON] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x85C1B4UL),
    [PARAM_FM_OP4_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x881A66UL),
    [PARAM_FM_OP4_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF1D97CUL),
    [PARAM_FM_OP4_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x97F2C0UL),
    [PARAM_FM_OP5_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x831386UL),
    [PARAM_FM_OP5_FREQ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD5718AUL),
    [PARAM_FM_OP5_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x1F46D5UL),
    [PARAM_FM_OP5_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x5BDD2CUL),
    [PARAM_FM_OP5_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x454516UL),
    [PARAM_FM_OP5_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x5B2419UL),
    [PARAM_FM_OP5_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4EAECDUL),
    [PARAM_FM_OP5_ON] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x9FDF89UL),
    [PARAM_FM_OP5_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x661333UL),
    [PARAM_FM_OP5_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE42E6BUL),
    [PARAM_FM_OP5_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xF4915FUL),
    [PARAM_FM_OP6_LEVEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x7BCFE7UL),
    [PARAM_FM_OP6_FREQ] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x23CC39UL),
    [PARAM_FM_OP6_DETUNE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x4AE2B2UL),
    [PARAM_FM_OP6_ENV_ATTACK] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xAC6C17UL),
    [PARAM_FM_OP6_ENV_DECAY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x6A7EF7UL),
    [PARAM_FM_OP6_ENV_SUSTAIN] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x55DF7CUL),
    [PARAM_FM_OP6_ENV_RELEASE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xD46814UL),
    [PARAM_FM_OP6_ON] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x80D512UL),
    [PARAM_FM_OP6_MODE] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x433410UL),
    [PARAM_FM_OP6_VEL] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0xE4F6CAUL),
    [PARAM_FM_OP6_KEY] = PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE, 0x2B128EUL),

};

static uint8_t param_scope(param_id_t id,persist_param_scope_t*out){if(out==NULL)return 0U;const track_runtime_param_rule_t rule=track_runtime_get_param_rule(id);if(rule.domain==TRACK_RUNTIME_PARAM_DOMAIN_GLOBAL&&rule.status==TRACK_RUNTIME_PARAM_GLOBAL_ALLOWED){*out=PERSIST_PARAM_SCOPE_GLOBAL;return 1U;}if(rule.domain!=TRACK_RUNTIME_PARAM_DOMAIN_NONE&&rule.domain!=TRACK_RUNTIME_PARAM_DOMAIN_GLOBAL&&rule.status==TRACK_RUNTIME_PARAM_ALLOWED){*out=PERSIST_PARAM_SCOPE_ENTITY;return 1U;}return 0U;}
static persist_control_value_kind_t param_kind(param_id_t id){(void)id;return PERSIST_VALUE_FLOAT32;}
uint8_t persist_key_param_descriptor(param_id_t id,persist_param_descriptor_t *out)
{
    if(out==NULL||id>=PARAM_COUNT||param_id_is_reserved(id))return 0U;
    if(g_param_keys[id]==0U)return 0U;
    out->key=g_param_keys[id];
    out->kind=param_kind(id);
    if(param_scope(id,&out->scope)==0U)return 0U;
    out->plockable=seq_param_iface_is_param_plockable(id);
    return 1U;
}
uint8_t persist_key_param_to_disk(param_id_t id,persist_control_parameter_key_t *out){persist_param_descriptor_t d;if(out==NULL||persist_key_param_descriptor(id,&d)==0U||d.key==0U)return 0U;*out=d.key;return 1U;}
uint8_t persist_key_param_from_disk(persist_control_parameter_key_t key,param_id_t *out){if(out==NULL||key==0U)return 0U;for(param_id_t id=0U;id<PARAM_COUNT;++id)if(!param_id_is_reserved(id)&&g_param_keys[id]==key){*out=id;return 1U;}return 0U;}
static const persist_control_parameter_key_t g_persist_tone_slot_keys[SEQ_PARAM_TONE_SLOT_COUNT]={
PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10001UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10002UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10003UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10004UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10005UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10006UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10007UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10008UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10009UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1000AUL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1000BUL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1000CUL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1000DUL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1000EUL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1000FUL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10010UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10011UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10012UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10013UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10014UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10015UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10016UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10017UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10018UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF10019UL),PERSIST_CONTROL_PARAMETER_KEY(PERSIST_PARAM_NAMESPACE_TONE,0xF1001AUL)};
uint8_t persist_key_tone_slot_to_disk(uint8_t slot,persist_control_parameter_key_t*out){if(out==NULL||slot>=SEQ_PARAM_TONE_SLOT_COUNT)return 0U;*out=g_persist_tone_slot_keys[slot];return 1U;}
uint8_t persist_key_tone_slot_from_disk(persist_control_parameter_key_t key,uint8_t*out_slot){if(out_slot==NULL||key==0U)return 0U;for(uint8_t slot=0U;slot<SEQ_PARAM_TONE_SLOT_COUNT;++slot)if(g_persist_tone_slot_keys[slot]==key){*out_slot=slot;return 1U;}return 0U;}
#define TO(v,k) case v:*out=k;return 1U;
#define FROM(v,k) case k:*out=v;return 1U;
uint8_t persist_key_family_to_disk(track_family_t v,persist_control_family_key_t*out){if(out==NULL)return 0U;switch(v){TO(TRACK_FAMILY_OFF,PERSIST_FAMILY_OFF)TO(TRACK_FAMILY_SYNTH,PERSIST_FAMILY_SYNTH)TO(TRACK_FAMILY_DRUM,PERSIST_FAMILY_DRUM)TO(TRACK_FAMILY_MIDI,PERSIST_FAMILY_MIDI)TO(TRACK_FAMILY_SAMPLER,PERSIST_FAMILY_SAMPLER)TO(TRACK_FAMILY_EXTERNAL,PERSIST_FAMILY_EXTERNAL)default:return 0U;}}
uint8_t persist_key_family_from_disk(persist_control_family_key_t k,track_family_t*out){if(out==NULL)return 0U;switch(k){FROM(TRACK_FAMILY_OFF,PERSIST_FAMILY_OFF)FROM(TRACK_FAMILY_SYNTH,PERSIST_FAMILY_SYNTH)FROM(TRACK_FAMILY_DRUM,PERSIST_FAMILY_DRUM)FROM(TRACK_FAMILY_MIDI,PERSIST_FAMILY_MIDI)FROM(TRACK_FAMILY_SAMPLER,PERSIST_FAMILY_SAMPLER)FROM(TRACK_FAMILY_EXTERNAL,PERSIST_FAMILY_EXTERNAL)default:return 0U;}}
uint8_t persist_key_type_to_disk(track_type_t v,persist_control_type_key_t*out){if(out==NULL)return 0U;switch(v){TO(TRACK_TYPE_NONE,PERSIST_TYPE_NONE)TO(TRACK_TYPE_PRISM,PERSIST_TYPE_PRISM)TO(TRACK_TYPE_WAVE,PERSIST_TYPE_WAVE)TO(TRACK_TYPE_STACK,PERSIST_TYPE_STACK)TO(TRACK_TYPE_FM,PERSIST_TYPE_FM)TO(TRACK_TYPE_DRUM_MD,PERSIST_TYPE_DRUM_MD)TO(TRACK_TYPE_DRUM_BD_ANALOG,PERSIST_TYPE_DRUM_ANALOG_BD)TO(TRACK_TYPE_MIDI,PERSIST_TYPE_MIDI)TO(TRACK_TYPE_RAM,PERSIST_TYPE_RAM_SAMPLE)TO(TRACK_TYPE_STREAM,PERSIST_TYPE_STREAM_SAMPLE)TO(TRACK_TYPE_MULTI,PERSIST_TYPE_MULTI_SAMPLE)TO(TRACK_TYPE_LOOPER,PERSIST_TYPE_LOOPER)TO(TRACK_TYPE_EXTERNAL,PERSIST_TYPE_EXTERNAL)TO(TRACK_TYPE_GROUP,PERSIST_TYPE_GROUP)default:return 0U;}}
uint8_t persist_key_type_from_disk(persist_control_type_key_t k,track_type_t*out){if(out==NULL)return 0U;switch(k){FROM(TRACK_TYPE_NONE,PERSIST_TYPE_NONE)FROM(TRACK_TYPE_PRISM,PERSIST_TYPE_PRISM)FROM(TRACK_TYPE_WAVE,PERSIST_TYPE_WAVE)FROM(TRACK_TYPE_STACK,PERSIST_TYPE_STACK)FROM(TRACK_TYPE_FM,PERSIST_TYPE_FM)FROM(TRACK_TYPE_DRUM_MD,PERSIST_TYPE_DRUM_MD)FROM(TRACK_TYPE_DRUM_BD_ANALOG,PERSIST_TYPE_DRUM_ANALOG_BD)FROM(TRACK_TYPE_MIDI,PERSIST_TYPE_MIDI)FROM(TRACK_TYPE_RAM,PERSIST_TYPE_RAM_SAMPLE)FROM(TRACK_TYPE_STREAM,PERSIST_TYPE_STREAM_SAMPLE)FROM(TRACK_TYPE_MULTI,PERSIST_TYPE_MULTI_SAMPLE)FROM(TRACK_TYPE_LOOPER,PERSIST_TYPE_LOOPER)FROM(TRACK_TYPE_EXTERNAL,PERSIST_TYPE_EXTERNAL)FROM(TRACK_TYPE_GROUP,PERSIST_TYPE_GROUP)default:return 0U;}}
#define SIMPLE_FUNCS(name,it,a,ka,b,kb,c,kc) uint8_t name##_to_disk(it v,uint32_t*out){if(out==NULL)return 0U;switch(v){TO(a,ka)TO(b,kb)TO(c,kc)default:return 0U;}}uint8_t name##_from_disk(uint32_t k,it*out){if(out==NULL)return 0U;switch(k){FROM(a,ka)FROM(b,kb)FROM(c,kc)default:return 0U;}}
SIMPLE_FUNCS(persist_key_midi_source,track_midi_source_t,TRACK_MIDI_SOURCE_INTERNAL,PERSIST_MIDI_SOURCE_INTERNAL,TRACK_MIDI_SOURCE_EXTERNAL,PERSIST_MIDI_SOURCE_EXTERNAL,TRACK_MIDI_SOURCE_ALL,PERSIST_MIDI_SOURCE_ALL)
SIMPLE_FUNCS(persist_key_clock,seq_clock_src_t,SEQ_CLOCK_SRC_INTERNAL,PERSIST_CLOCK_INTERNAL,SEQ_CLOCK_SRC_EXTERNAL_MIDI,PERSIST_CLOCK_MIDI,SEQ_CLOCK_SRC_EXTERNAL_USB,PERSIST_CLOCK_USB)
SIMPLE_FUNCS(persist_key_note_fx,note_fx_model_t,NOTE_FX_MODEL_OFF,PERSIST_NOTE_FX_OFF,NOTE_FX_MODEL_ARP,PERSIST_NOTE_FX_ARP,NOTE_FX_MODEL_EUCLID,PERSIST_NOTE_FX_EUCLID)
static const uint32_t lfo_shapes[]={PERSIST_LFO_SHAPE_SINE,PERSIST_LFO_SHAPE_TRIANGLE,PERSIST_LFO_SHAPE_SAW,PERSIST_LFO_SHAPE_SQUARE,PERSIST_LFO_SHAPE_RANDOM_SH,PERSIST_LFO_SHAPE_SINE_POS,PERSIST_LFO_SHAPE_TRIANGLE_POS,PERSIST_LFO_SHAPE_SQUARE_POS,PERSIST_LFO_SHAPE_REVERSE_SAW};
uint8_t persist_key_lfo_shape_to_disk(mod_lfo_shape_t v,uint32_t*out){if(out==NULL||(uint8_t)v>=MOD_LFO_SHAPE_COUNT)return 0U;*out=lfo_shapes[v];return 1U;}uint8_t persist_key_lfo_shape_from_disk(uint32_t k,mod_lfo_shape_t*out){if(out==NULL)return 0U;for(uint8_t i=0U;i<MOD_LFO_SHAPE_COUNT;++i)if(lfo_shapes[i]==k){*out=(mod_lfo_shape_t)i;return 1U;}return 0U;}
static const uint32_t lfo_triggers[]={PERSIST_LFO_TRIGGER_FREE,PERSIST_LFO_TRIGGER_TRIG,PERSIST_LFO_TRIGGER_HOLD,PERSIST_LFO_TRIGGER_ONE,PERSIST_LFO_TRIGGER_POLY_TRIG,PERSIST_LFO_TRIGGER_POLY_HOLD,PERSIST_LFO_TRIGGER_POLY_ONE};
uint8_t persist_key_lfo_trigger_to_disk(mod_lfo_trig_mode_t v,uint32_t*out){if(out==NULL||(uint8_t)v>=MOD_LFO_TRIG_COUNT)return 0U;*out=lfo_triggers[v];return 1U;}uint8_t persist_key_lfo_trigger_from_disk(uint32_t k,mod_lfo_trig_mode_t*out){if(out==NULL)return 0U;for(uint8_t i=0U;i<MOD_LFO_TRIG_COUNT;++i)if(lfo_triggers[i]==k){*out=(mod_lfo_trig_mode_t)i;return 1U;}return 0U;}
static const uint32_t mod_sources[]={PERSIST_MOD_SOURCE_NONE,PERSIST_MOD_SOURCE_LFO1,PERSIST_MOD_SOURCE_LFO2,PERSIST_MOD_SOURCE_LFO3,PERSIST_MOD_SOURCE_ENV_FLT,PERSIST_MOD_SOURCE_ENV_VCA,PERSIST_MOD_SOURCE_ENV_MOD,PERSIST_MOD_SOURCE_MULTI1,PERSIST_MOD_SOURCE_MULTI2,PERSIST_MOD_SOURCE_SLEW1,PERSIST_MOD_SOURCE_SLEW2};
uint8_t persist_key_mod_source_to_disk(uint8_t v,uint32_t*out){if(out==NULL||v>=11U)return 0U;*out=mod_sources[v];return 1U;}uint8_t persist_key_mod_source_from_disk(uint32_t k,uint8_t*out){if(out==NULL)return 0U;for(uint8_t i=0U;i<11U;++i)if(mod_sources[i]==k){*out=i;return 1U;}return 0U;}
static const uint32_t rec_start[]={PERSIST_RECORD_START_DEFAULT,PERSIST_RECORD_START_TRIGGER,PERSIST_RECORD_START_ROLL_QUARTER,PERSIST_RECORD_START_ROLL_HALF,PERSIST_RECORD_START_ROLL_BAR};static const uint32_t rec_len[]={PERSIST_RECORD_LENGTH_OVERDUB,PERSIST_RECORD_LENGTH_PATTERN};
static uint8_t array_to(uint8_t v,const uint32_t*a,uint8_t n,uint32_t*out){if(out==NULL||v>=n)return 0U;*out=a[v];return 1U;}static uint8_t array_from(uint32_t k,const uint32_t*a,uint8_t n,uint8_t*out){if(out==NULL)return 0U;for(uint8_t i=0U;i<n;++i)if(a[i]==k){*out=i;return 1U;}return 0U;}
uint8_t persist_key_record_start_to_disk(uint8_t v,uint32_t*out){return array_to(v,rec_start,5U,out);}uint8_t persist_key_record_start_from_disk(uint32_t k,uint8_t*out){return array_from(k,rec_start,5U,out);}uint8_t persist_key_record_length_to_disk(uint8_t v,uint32_t*out){return array_to(v,rec_len,2U,out);}uint8_t persist_key_record_length_from_disk(uint32_t k,uint8_t*out){return array_from(k,rec_len,2U,out);}
uint8_t persist_key_input_to_disk(uint8_t v,uint32_t*out){if(out==NULL)return 0U;if(v==ENTITY_AUDIO_SOURCE_LINE){*out=PERSIST_INPUT_LINE;return 1U;}if(v==ENTITY_AUDIO_SOURCE_USB){*out=PERSIST_INPUT_USB;return 1U;}return 0U;}uint8_t persist_key_input_from_disk(uint32_t k,uint8_t*out){if(out==NULL)return 0U;if(k==PERSIST_INPUT_LINE){*out=ENTITY_AUDIO_SOURCE_LINE;return 1U;}if(k==PERSIST_INPUT_USB){*out=ENTITY_AUDIO_SOURCE_USB;return 1U;}return 0U;}
uint8_t persist_key_mod_destination_to_disk(uint8_t e,param_id_t p,persist_control_entity_id_t*oe,persist_control_parameter_key_t*op){if(oe==NULL||op==NULL||e>=PERSIST_CONTROL_ENTITY_COUNT||persist_key_param_to_disk(p,op)==0U)return 0U;*oe=e;return 1U;}
uint8_t persist_key_mod_destination_from_disk(persist_control_entity_id_t e,persist_control_parameter_key_t p,uint8_t active,uint8_t*oe,param_id_t*op){entity_topology_descriptor_t d;if(oe==NULL||op==NULL||entity_topology_resolve(active,e,&d)==0U||d.active==0U||persist_key_param_from_disk(p,op)==0U)return 0U;*oe=e;return 1U;}
